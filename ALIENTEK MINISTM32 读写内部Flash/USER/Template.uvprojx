# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Hardware;..\SYSTEM;..\SYSTEM\Timer;..\SYSTEM\MyRTC;..\SYSTEM\Flash;..\SYSTEM\Store
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/Timer/: Timer.c Timer.h
    ../SYSTEM/MyRTC/: MyRTC.c MyRTC.h
    ../SYSTEM/Flash/: MyFlash.c MyFlash.h
    ../SYSTEM/Store/: Store.c Store.h
  group Hardware
    ../Hardware/: LED.c LED.h KEY.c KEY.h Buzzer.c Buzzer.h LightSensor.c LightSensor.h FONT.H lcd.c lcd.h CountSensor.c CountSensor.h Encoder.c Encoder.h AD.c AD.h Serial.c MPU6050.c MPU6050.h MPU6050_Reg.h MySPI.c MySPI.h W25Q64.c W25Q64.h W25Q64_Inc.h
    ./: Serial.h
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
